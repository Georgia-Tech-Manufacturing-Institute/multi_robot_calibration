Commit message: remove tool0 rotation in urdf

File: robot_data/za_description/urdf/za.urdf (robot description, URDF)
Before this commit: robot za, 11 links, 10 joints
Joints:
- joint link_6-tool0: origin xyz=0 0 0 rpy=0 1.5707963267948966 0 -> xyz=0 0 0 rpy=0 0 0
